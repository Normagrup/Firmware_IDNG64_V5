# Keil uVision project IDNG64v5.uvprojx, settings and files
target IDNG64v5 (5060528::V5.06 update 5 (build 528)::.\5.06)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Code_Porting +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\MDK-ARM;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x8004000 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_iwdg.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group STM32G070
    ./: board.c board.h tasks.c tasks.h
  group User
    ../app/: ethFramming.c ethFramming.h ethTransceiver.c ethTransceiver.h ethPing.c actualLevel.c botonera.c config.c dADSA.c dali.c daliAddressing.c daliCommands.c daliLoop.c daliSensores.c daliTransceiver.c daliUtils.c dALS.c dANI.c dAPSA.c dAQCGL.c dAQDTL.c dASE.c dASRA.c debug.c embeddedBootloader.c fallos.c historico.c historicoTest.c iED.c interfaces.c loop.c m25p.c normalink.c normaLink62386P102.c normaLink62386P202.c normaLink62386P209.c normaLinkCfgInfoPasarela.c normaLinkCmdPasarela.c normaLinkDaliUtils.c normaLinkSensores.c normaLinkSingleLoop.c polling.c qSN.c rtcc.c sensores.c sensoresConfig.c sensors.c sensorScanning.c sensorStoring.c spi1.c spi2.c storage.c systick.c temp.c test.c utils.c wdt.c webserver.c
    ../app/sensoresGrupos/: sensoresGrupos.c sensoresGruposDetectoresPresencia.c sensoresGruposPulsadoresAccionBasculante.c sensoresGruposPulsadoresAccionFija.c sensoresGruposPulsadoresAccionRegulacion.c sensoresGruposPulsadoresAccionTemporizada.c sensoresGruposPulsadoresTW.c sensoresGruposReguladoresLuz.c
    ../app/w5100/: md5.c md5.h readme.txt socket.c socket.h types.h w5100.c w5100.h
software components: CMSIS:CORE 5.6.0
